options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: clock_drift_test
    output_language: python
    title: Clock Drift Synchronization Test
  states: {}

blocks:
- name: Tc
  id: variable
  parameters:
    value: '750e-6'
  states: {}
- name: Tp
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: baseband_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: prf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: harmonia_buffer_corrector_0
  id: harmonia_buffer_corrector
  parameters:
    max_buffer_size: '1996'
  states: {}
- name: harmonia_clock_drift_est_0
  id: harmonia_clock_drift_est
  parameters:
    SNR: '34'
    baseband_freq: baseband_freq
    center_freq: center_freq
    num_platforms: '3'
    platform_num: '1'
    pulse_width: Tp
    samp_rate: samp_rate
  states: {}
- name: harmonia_frequency_pk_est_0
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: '15'
    backend: harmonia.Device.CPU
    cap_length: Tc
    current_sdr: PMT_HARMONIA_SDR1
    depth: '1'
    enable_out: 'True'
    nfft: '12'
    pulse_width: Tp
    samp_rate: samp_rate
  states: {}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    duration_key: radar:duration
    frequency: baseband_freq
    frequency_key: radar:frequency
    label_key: core:label
    phase: '0'
    phase_key: radar:phase
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    TDMA_time: '50e-3'
    args_1: '"addr=192.168.60.2, use_dpkg=1"'
    args_2: '"addr=192.168.80.2, use_dpkg=1"'
    cap_length: Tc
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '0'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '0'
    start_delay: '0.001'
    verbose: 'False'
    wait_time: Tc/2
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/freq_pk_est_test
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'True'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/TDMA_test
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'True'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waverform
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_float
  states: {state: disabled}

connections:
- [harmonia_buffer_corrector_0, out, harmonia_usrp_radar_all_0, in]
- [harmonia_buffer_corrector_0, out, plasma_pdu_file_sink_0_0_0, in]
- [harmonia_clock_drift_est_0, out, blocks_message_debug_0_0, print]
- [harmonia_frequency_pk_est_0, f_out, blocks_message_debug_0, print]
- [harmonia_frequency_pk_est_0, f_out, harmonia_clock_drift_est_0, in]
- [harmonia_frequency_pk_est_0, out, plasma_pdu_file_sink_0, in]
- [harmonia_frequency_pk_est_0, out, qtgui_time_sink_x_0_1_0, in]
- [harmonia_single_tone_src_0, out, harmonia_buffer_corrector_0, in]
- [harmonia_single_tone_src_0, out, qtgui_time_sink_x_0, in]
- [harmonia_usrp_radar_all_0, out, harmonia_frequency_pk_est_0, in]
- [harmonia_usrp_radar_all_0, out, plasma_pdu_file_sink_0_0, in]
- [harmonia_usrp_radar_all_0, out, qtgui_time_sink_x_0_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
