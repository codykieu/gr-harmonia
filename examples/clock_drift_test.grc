options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: clock_drift_test
    output_language: python
    title: Clock Drift Synchronization Test
  states: {}

blocks:
- name: Tc
  id: variable
  parameters:
    value: '600e-6'
  states: {}
- name: Tp
  id: variable
  parameters:
    value: '300e-6'
  states: {}
- name: baseband_freq
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: prf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: run_id
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: harmonia_clock_drift_est_0
  id: harmonia_clock_drift_est
  parameters:
    SNR: '34'
    baseband_freq: baseband_freq
    center_freq: center_freq
    num_platforms: '3'
    platform_num: '1'
    pulse_width: Tp
    samp_rate: samp_rate
  states: {}
- name: harmonia_frequency_pk_est_0
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: '10'
    backend: harmonia.Device.CPU
    cap_length: Tc
    current_sdr: PMT_HARMONIA_SDR1
    depth: '1'
    enable_out: 'True'
    nfft: '16'
    pulse_width: Tp
    samp_rate: samp_rate
  states: {}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    center_freq: center_freq
    duration_key: radar:duration
    frequency: baseband_freq
    frequency_key: radar:frequency
    label_key: core:label
    max_buffer_size: '1996'
    phase: '0'
    phase_key: radar:phase
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '3'
  states: {}
- name: harmonia_single_tone_src_0_0
  id: harmonia_single_tone_src
  parameters:
    center_freq: center_freq
    duration_key: radar:duration
    frequency: baseband_freq
    frequency_key: radar:frequency
    label_key: core:label
    max_buffer_size: '1996'
    phase: '0'
    phase_key: radar:phase
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
  states: {}
- name: harmonia_single_tone_src_0_1
  id: harmonia_single_tone_src
  parameters:
    center_freq: center_freq
    duration_key: radar:duration
    frequency: baseband_freq
    frequency_key: radar:frequency
    label_key: core:label
    max_buffer_size: '1996'
    phase: '0'
    phase_key: radar:phase
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '2'
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    TDMA_time: '150e-3'
    args_1: '"addr=192.168.60.2, use_dpkg=1"'
    args_2: '"addr=192.168.80.2, use_dpkg=1"'
    cap_length: Tc
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '0'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '0'
    start_delay: '0.003'
    verbose: 'False'
    wait_time: '200e-6'
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/freq_pk_est_test
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'True'
    type: float
  states: {}
- name: plasma_pdu_file_sink_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/clock_drift_pre
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'True'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waverform
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {state: disabled}
- name: plasma_pdu_file_sink_0_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waverform2
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {state: disabled}
- name: plasma_pdu_file_sink_0_0_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: ''
    meta_filename: f'/home/cody/gr-MATLAB/clock_drift_test_1mhz/clock_drift_est{run_id}'
    save_meta: 'True'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/clock_drift_post
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clock_est
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sdr1_wav
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: sdr2_wav
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: sdr3_wav
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: clock_est
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: clock_est
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: clock_est
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: sdr1_wav
  states: {}
- name: virtual_source_0_3_0
  id: virtual_source
  parameters:
    stream_id: sdr3_wav
  states: {}
- name: virtual_source_0_3_1
  id: virtual_source
  parameters:
    stream_id: sdr2_wav
  states: {}

connections:
- [harmonia_clock_drift_est_0, out, blocks_message_debug_0, print]
- [harmonia_clock_drift_est_0, out, plasma_pdu_file_sink_0_0_0_0_0, in]
- [harmonia_clock_drift_est_0, out, virtual_sink_0, '0']
- [harmonia_frequency_pk_est_0, f_out, blocks_message_debug_0_0, print]
- [harmonia_frequency_pk_est_0, f_out, harmonia_clock_drift_est_0, in]
- [harmonia_frequency_pk_est_0, out, plasma_pdu_file_sink_0, in]
- [harmonia_single_tone_src_0, out, virtual_sink_0_0_1, '0']
- [harmonia_single_tone_src_0_0, out, plasma_pdu_file_sink_0_0_0, in]
- [harmonia_single_tone_src_0_0, out, virtual_sink_0_0, '0']
- [harmonia_single_tone_src_0_1, out, plasma_pdu_file_sink_0_0_0_0, in]
- [harmonia_single_tone_src_0_1, out, virtual_sink_0_0_0, '0']
- [harmonia_usrp_radar_all_0, out, harmonia_frequency_pk_est_0, in]
- [harmonia_usrp_radar_all_0, out, plasma_pdu_file_sink_0_0, in]
- [harmonia_usrp_radar_all_0, out2, plasma_pdu_file_sink_0_0_1, in]
- [virtual_source_0_0, '0', harmonia_single_tone_src_0_0, in]
- [virtual_source_0_1, '0', harmonia_single_tone_src_0_1, in]
- [virtual_source_0_2, '0', harmonia_single_tone_src_0, in]
- [virtual_source_0_3, '0', harmonia_usrp_radar_all_0, in]
- [virtual_source_0_3_0, '0', harmonia_usrp_radar_all_0, in3]
- [virtual_source_0_3_1, '0', harmonia_usrp_radar_all_0, in2]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
