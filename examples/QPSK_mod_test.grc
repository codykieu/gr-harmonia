options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: QPSK_mod_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons( pmt.make_dict(),pmt.init_f32vector(2, [1222, 2392]) )
    period: '3000'
  states: {}
- name: harmonia_QPSK_demod_0
  id: harmonia_QPSK_demod
  parameters:
    sps: '8'
  states: {}
- name: harmonia_QPSK_mod_0
  id: harmonia_QPSK_mod
  parameters:
    spb: '8'
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    TDMA_time: '2e-6'
    args_1: '"addr=192.168.60.2, use_dpkg=1"'
    args_2: '"addr=192.168.80.2, use_dpkg=1"'
    cap_length: '0.01'
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '0'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '0'
    start_delay: '0.2'
    verbose: 'False'
    wait_time: '0.001'
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/qpsk_test
    meta_filename: ''
    save_meta: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}

connections:
- [blocks_message_strobe_0, strobe, harmonia_QPSK_mod_0, in]
- [harmonia_QPSK_demod_0, out, blocks_message_debug_0, log]
- [harmonia_QPSK_mod_0, out, harmonia_QPSK_demod_0, in]
- [harmonia_QPSK_mod_0, out, harmonia_usrp_radar_all_0, in]
- [harmonia_QPSK_mod_0, out, qtgui_time_sink_x_0, in]
- [harmonia_usrp_radar_all_0, out, harmonia_QPSK_demod_0, in]
- [harmonia_usrp_radar_all_0, out, plasma_pdu_file_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
