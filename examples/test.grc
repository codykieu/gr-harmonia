options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: harmonia_buffer_corrector_0
  id: harmonia_buffer_corrector
  parameters:
    max_buffer_size: '1996'
  states: {state: bypassed}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    center_freq: '0'
    duration_key: radar:duration
    frequency: '0'
    frequency_key: radar:frequency
    label_key: core:label
    max_buffer_size: '1996'
    phase: '0'
    phase_key: radar:phase
    prf: '0'
    prf_key: radar:prf
    pulse_width: '300e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
  states: {}
- name: harmonia_usrp_radar_2_0
  id: harmonia_usrp_radar_2
  parameters:
    args_rx: '"addr=192.168.80.2, use_dpkg=1"'
    args_tx: '"addr=192.168.60.2, use_dpkg=1"'
    cal_file: '""'
    elevate_priority: 'False'
    prf_key: radar:prf
    rx_freq: 3e9
    rx_freq_key: core:rx_freq
    rx_gain: '0'
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    start_delay: '0.1'
    tx_freq: 3e9
    tx_freq_key: core:tx_freq
    tx_gain: '0'
    verbose: 'False'
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waveform
    meta_filename: ''
    save_meta: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}

connections:
- [harmonia_buffer_corrector_0, out, harmonia_usrp_radar_2_0, in]
- [harmonia_single_tone_src_0, out, harmonia_buffer_corrector_0, in]
- [harmonia_usrp_radar_2_0, out, plasma_pdu_file_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
