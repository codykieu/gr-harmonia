options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    center_freq: '0'
    duration_key: radar:duration
    frequency: 10e3
    frequency_key: radar:frequency
    label_key: core:label
    max_buffer_size: '1996'
    phase: '0'
    phase_key: radar:phase
    prf: '0'
    prf_key: radar:prf
    pulse_width: '300e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waveform
    meta_filename: /home/cody/gr-MATLAB/waveform_meta
    save_meta: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}

connections:
- [harmonia_single_tone_src_0, out, plasma_pdu_file_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
