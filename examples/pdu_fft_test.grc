options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: PDU_FFT_test
    output_language: python
    title: PDU_FFT_test
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: harmonia_frequency_pk_est_0
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: '15'
    NLLS_pts: '7'
    backend: harmonia.Device.DEFAULT
    cap_length: '400e-6'
    depth: '1'
    enable_out: 'True'
    fft_size: fft_size
    nfft: '4'
    pulse_width: '200e-6'
    samp_rate: samp_rate
  states: {}
- name: harmonia_frequency_pk_est_1
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: '15'
    NLLS_pts: '7'
    backend: harmonia.Device.DEFAULT
    cap_length: '400e-6'
    depth: '1'
    enable_out: 'True'
    fft_size: fft_size
    nfft: '1024'
    pulse_width: '200e-6'
    samp_rate: samp_rate
  states: {state: disabled}
- name: harmonia_pdu_complex_to_mag_0_0_0
  id: harmonia_pdu_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: harmonia_pdu_complex_to_mag_0_0_0_0
  id: harmonia_pdu_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: harmonia_pdu_fft_0
  id: harmonia_pdu_fft
  parameters:
    backend: plasma.Device.DEFAULT
    depth: '1'
    fft_size: fft_size
    nfft: '1024'
  states: {state: disabled}
- name: harmonia_pdu_fft_1
  id: harmonia_pdu_fft
  parameters:
    backend: plasma.Device.DEFAULT
    depth: '1'
    fft_size: fft_size
    nfft: '1024'
  states: {state: disabled}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    duration_key: radar:duration
    frequency: 1e6
    frequency_key: radar:frequency
    label_key: core:label
    phase: '0'
    phase_key: radar:phase
    prf: '0'
    prf_key: radar:prf
    pulse_width: '10e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: 50e6
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '200e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-25e6'
    start_freq_key: radar:start_freq
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    type: msg_complex
    wintype: window.WIN_RECTANGULAR
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [harmonia_frequency_pk_est_0, f_out, blocks_message_debug_0_0, store]
- [harmonia_frequency_pk_est_0, out, qtgui_time_sink_x_0_0_0_1, in]
- [harmonia_frequency_pk_est_1, f_out, blocks_message_debug_0, store]
- [harmonia_frequency_pk_est_1, out, qtgui_time_sink_x_0_0_0, in]
- [harmonia_pdu_complex_to_mag_0_0_0, out, qtgui_time_sink_x_0_0_0_0_0, in]
- [harmonia_pdu_complex_to_mag_0_0_0_0, out, qtgui_time_sink_x_0_0_0_0, in]
- [harmonia_pdu_fft_0, out, harmonia_pdu_complex_to_mag_0_0_0, in]
- [harmonia_pdu_fft_1, out, harmonia_pdu_complex_to_mag_0_0_0_0, in]
- [harmonia_single_tone_src_0, out, harmonia_frequency_pk_est_0, in]
- [harmonia_single_tone_src_0, out, qtgui_time_sink_x_0, in]
- [plasma_lfm_source_0, out, harmonia_frequency_pk_est_1, in]
- [plasma_lfm_source_0, out, harmonia_pdu_fft_1, in]
- [plasma_lfm_source_0, out, qtgui_freq_sink_x_0, in]
- [plasma_lfm_source_0, out, qtgui_time_sink_x_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
