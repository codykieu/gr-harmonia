options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: USRP_TX_RX
    output_language: python
    title: USRP TX and RX  (same block)
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    duration_key: radar:duration
    frequency: 1e6
    frequency_key: radar:frequency
    label_key: core:label
    phase: '0'
    phase_key: radar:phase
    prf: '0'
    prf_key: radar:prf
    pulse_width: '100e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: harmonia_usrp_radar_2_0
  id: harmonia_usrp_radar_2
  parameters:
    args_rx: '"addr=192.168.80.2, use_dpkg=1"'
    args_tx: '"addr=192.168.60.2, use_dpkg=1"'
    cal_file: '""'
    elevate_priority: 'False'
    prf_key: radar:prf
    rx_freq: center_freq
    rx_freq_key: core:rx_freq
    rx_gain: '10'
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    start_delay: '0.1'
    tx_freq: center_freq
    tx_freq_key: core:tx_freq
    tx_gain: '10'
    verbose: 'False'
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/freq_pk_est_test
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: msg_complex
  states: {}

connections:
- [harmonia_single_tone_src_0, out, harmonia_usrp_radar_2_0, in]
- [harmonia_usrp_radar_2_0, out, plasma_pdu_file_sink_0, in]
- [harmonia_usrp_radar_2_0, out, qtgui_time_sink_x_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
