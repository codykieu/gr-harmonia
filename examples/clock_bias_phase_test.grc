options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: cb_phase_test
    output_language: python
    title: Clock Bias and Phase test
  states: {}

blocks:
- name: Tc
  id: variable
  parameters:
    value: '100e-3'
  states: {}
- name: Tp
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: bw
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: prf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: harmonia_buffer_corrector_0
  id: harmonia_buffer_corrector
  parameters:
    max_buffer_size: '1996'
  states: {}
- name: harmonia_clockbias_phase_est_0
  id: harmonia_clockbias_phase_est
  parameters:
    SNR: '0'
    baseband_freq: 1e6
    center_freq: center_freq
    num_platforms: '3'
    platform_num: '1'
    pulse_width: Tp
    samp_rate: samp_rate
  states: {}
- name: harmonia_time_pk_est_0
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: '15'
    NLLS_pts: '7'
    backend: plasma.Device.DEFAULT
    bandwidth: bw
    current_sdr: PMT_HARMONIA_SDR1
    depth: '1'
    nfft: '4'
    samp_rate: samp_rate
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    TDMA_time: '2e-6'
    args_1: '"addr=192.168.60.2, use_dpkg=1"'
    args_2: '"addr=192.168.80.2, use_dpkg=1"'
    cap_length: Tc
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '20'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '20'
    start_delay: '0.005'
    verbose: 'False'
    wait_time: '1'
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bw/2 + center_freq'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_pdu_file_sink_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/TDMA_test
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'True'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waverform
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_sig
  states: {}

connections:
- [harmonia_buffer_corrector_0, out, harmonia_usrp_radar_all_0, in]
- [harmonia_clockbias_phase_est_0, out, blocks_message_debug_0_0, print]
- [harmonia_time_pk_est_0, tp_out, blocks_message_debug_0, print]
- [harmonia_time_pk_est_0, tp_out, harmonia_clockbias_phase_est_0, in]
- [harmonia_usrp_radar_all_0, out, harmonia_time_pk_est_0, rx]
- [harmonia_usrp_radar_all_0, out, plasma_pdu_file_sink_0_0, in]
- [harmonia_usrp_radar_all_0, out, qtgui_time_sink_x_0_1, in]
- [plasma_lfm_source_0, out, harmonia_buffer_corrector_0, in]
- [plasma_lfm_source_0, out, plasma_pdu_file_sink_0_0_0, in]
- [plasma_lfm_source_0, out, virtual_sink_0, '0']
- [virtual_source_0, '0', harmonia_time_pk_est_0, tx]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
