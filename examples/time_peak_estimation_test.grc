options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: time_peak_estimation_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: FE_delay
  id: variable
  parameters:
    value: '81.715'
  states: {}
- name: NLLS_iter
  id: variable
  parameters:
    value: '6'
  states: {}
- name: Tc
  id: variable
  parameters:
    value: '9e-3'
  states: {}
- name: Tc2
  id: variable
  parameters:
    value: '500e-6'
  states: {}
- name: Tp
  id: variable
  parameters:
    value: '0.05e-3'
  states: {}
- name: Tp2
  id: variable
  parameters:
    value: '50e-6'
  states: {}
- name: Tp_st
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: Tw
  id: variable
  parameters:
    value: '4e-3'
  states: {}
- name: Tw2
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: Zpad
  id: variable
  parameters:
    value: '400'
  states: {}
- name: baseband_freq
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: bw
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: prf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: run_id
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: tdma_time
  id: variable
  parameters:
    value: '15e-3'
  states: {}
- name: tdma_time2
  id: variable
  parameters:
    value: '1000e-6'
  states: {}
- name: harmonia_LFM_src_0
  id: harmonia_LFM_src
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    center_freq: center_freq
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp
    pulse_width2: Tp2
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
    start_freq: '-bw/2'
    zeropad: Zpad
  states: {}
- name: harmonia_LFM_src_0_0
  id: harmonia_LFM_src
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    center_freq: center_freq
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp
    pulse_width2: Tp2
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '2'
    start_freq: '-bw/2'
    zeropad: Zpad
  states: {}
- name: harmonia_LFM_src_0_1
  id: harmonia_LFM_src
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    center_freq: center_freq
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp
    pulse_width2: Tp2
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '3'
    start_freq: '-bw/2'
    zeropad: Zpad
  states: {}
- name: harmonia_LFM_src_0_2
  id: harmonia_LFM_src
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    center_freq: center_freq
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp
    pulse_width2: Tp2
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
    start_freq: '-bw/2'
    zeropad: Zpad
  states: {}
- name: harmonia_LFM_src_0_2_0
  id: harmonia_LFM_src
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    center_freq: center_freq
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp2
    pulse_width2: Tp2
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
    start_freq: '-bw/2'
    zeropad: Zpad
  states: {}
- name: harmonia_clock_drift_est_0
  id: harmonia_clock_drift_est
  parameters:
    SNR: '0'
    baseband_freq: baseband_freq
    center_freq: center_freq
    num_platforms: '3'
    pulse_width: Tp
    samp_rate: samp_rate
  states: {}
- name: harmonia_clockbias_phase_est_0
  id: harmonia_clockbias_phase_est
  parameters:
    SNR: '0'
    bias_status: 'True'
    center_freq: center_freq
    num_platforms: '3'
    phase_status: 'False'
    pulse_width: Tp
    samp_rate: samp_rate
  states: {}
- name: harmonia_clockbias_phase_est_0_0
  id: harmonia_clockbias_phase_est
  parameters:
    SNR: '0'
    bias_status: 'False'
    center_freq: center_freq
    num_platforms: '3'
    phase_status: 'True'
    pulse_width: Tp2
    samp_rate: samp_rate
  states: {}
- name: harmonia_compensation_0
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '1'
  states: {}
- name: harmonia_compensation_0_0
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '2'
  states: {}
- name: harmonia_compensation_0_0_0
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '2'
  states: {}
- name: harmonia_compensation_0_0_0_0
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '2'
  states: {}
- name: harmonia_compensation_0_1
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '3'
  states: {}
- name: harmonia_compensation_0_1_0
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '3'
  states: {}
- name: harmonia_compensation_0_1_0_0
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '3'
  states: {}
- name: harmonia_compensation_0_2
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '1'
  states: {}
- name: harmonia_compensation_0_2_0
  id: harmonia_compensation
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    sdr_id: '1'
  states: {}
- name: harmonia_frequency_pk_est_0
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.CPU
    cap_length: Tc
    depth: '1'
    enable_out: 'False'
    fft_ratio: '12'
    pulse_width: Tp
    samp_rate: samp_rate
    sdr_id: '1'
  states: {}
- name: harmonia_frequency_pk_est_0_0
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.CPU
    cap_length: Tc
    depth: '1'
    enable_out: 'False'
    fft_ratio: '12'
    pulse_width: Tp
    samp_rate: samp_rate
    sdr_id: '3'
  states: {}
- name: harmonia_frequency_pk_est_0_1
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.CPU
    cap_length: Tc
    depth: '1'
    enable_out: 'False'
    fft_ratio: '12'
    pulse_width: Tp
    samp_rate: samp_rate
    sdr_id: '2'
  states: {}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    center_freq: center_freq
    duration_key: radar:duration
    frequency: baseband_freq
    frequency_key: radar:frequency
    label_key: core:label
    phase: '0'
    phase_key: radar:phase
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp_st
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '3'
  states: {}
- name: harmonia_single_tone_src_0_0
  id: harmonia_single_tone_src
  parameters:
    center_freq: center_freq
    duration_key: radar:duration
    frequency: baseband_freq
    frequency_key: radar:frequency
    label_key: core:label
    phase: '0'
    phase_key: radar:phase
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp_st
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
  states: {}
- name: harmonia_single_tone_src_0_1
  id: harmonia_single_tone_src
  parameters:
    center_freq: center_freq
    duration_key: radar:duration
    frequency: baseband_freq
    frequency_key: radar:frequency
    label_key: core:label
    phase: '0'
    phase_key: radar:phase
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp_st
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '2'
  states: {}
- name: harmonia_time_pk_est_0
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.DEFAULT
    bandwidth: bw
    depth: '1'
    enable_out: 'False'
    samp_rate: samp_rate
    sample_delay: 'FE_delay '
    sdr_id: '1'
    wait_time: Tw
  states: {}
- name: harmonia_time_pk_est_0_0
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.DEFAULT
    bandwidth: bw
    depth: '1'
    enable_out: 'False'
    samp_rate: samp_rate
    sample_delay: 'FE_delay '
    sdr_id: '2'
    wait_time: Tw
  states: {}
- name: harmonia_time_pk_est_0_0_0
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.DEFAULT
    bandwidth: bw
    depth: '1'
    enable_out: 'False'
    samp_rate: samp_rate
    sample_delay: FE_delay
    sdr_id: '2'
    wait_time: Tw2
  states: {}
- name: harmonia_time_pk_est_0_1
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.DEFAULT
    bandwidth: bw
    depth: '1'
    enable_out: 'False'
    samp_rate: samp_rate
    sample_delay: FE_delay
    sdr_id: '3'
    wait_time: Tw
  states: {}
- name: harmonia_time_pk_est_0_1_0
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.DEFAULT
    bandwidth: bw
    depth: '1'
    enable_out: 'False'
    samp_rate: samp_rate
    sample_delay: FE_delay
    sdr_id: '3'
    wait_time: Tw2
  states: {}
- name: harmonia_time_pk_est_0_2
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: NLLS_iter
    backend: harmonia.Device.DEFAULT
    bandwidth: bw
    depth: '1'
    enable_out: 'False'
    samp_rate: samp_rate
    sample_delay: FE_delay
    sdr_id: '1'
    wait_time: Tw2
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    TDMA_time: tdma_time
    TDMA_time2: tdma_time2
    args_1: '"addr=192.168.40.2,ignore-cal-file=0"'
    args_2: '"addr=192.168.60.2,ignore-cal-file=0"'
    args_3: '"addr=192.168.80.2,ignore-cal-file=0"'
    cap_length: Tc
    cap_length2: Tc2
    lfm_only: 'False'
    loopback: 'False'
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '15'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '15'
    sdr3_freq: center_freq
    sdr3_gain: '15'
    start_delay: '1.5'
    verbose: 'False'
    wait_time: Tw
    wait_time2: Tw2
  states: {}
- name: plasma_pdu_file_sink_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/st1
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waveform1
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: ''
    meta_filename: f'/home/cody/gr-MATLAB/clock_drift_test2/clock_drift_est{run_id}'
    save_meta: 'True'
    type: complex
  states: {state: disabled}
- name: plasma_pdu_file_sink_0_0_0_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: ''
    meta_filename: f'/home/cody/gr-MATLAB/range_test/range_est{run_id}'
    save_meta: 'True'
    type: complex
  states: {state: disabled}
- name: plasma_pdu_file_sink_0_0_0_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waveform2
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_0_2
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/waveform3
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/cd_lfm1
    meta_filename: /home/cody/gr-MATLAB/meta_test
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_1_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/cb_lfm1
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/st2
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/cd_lfm2
    meta_filename: /home/cody/gr-MATLAB/meta_test2
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/cb_lfm2
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/comp1
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_0_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/comp2
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_0_2
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/comp3
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/post_fd1
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_1_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/post_fd2
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_1_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/post_cb1
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_1_0_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/post_cb2
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_1_0_0_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/post_cb3
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_2_0_1_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/post_fd3
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_3
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/st3
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_3_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/cd_lfm3
    meta_filename: /home/cody/gr-MATLAB/meta_test3
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_3_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/cb_lfm3
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_3_0_0_0_1_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/final_rx_comp1
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_3_0_0_0_1_1_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/final_rx_comp2
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0_3_0_0_0_1_1_1
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/final_rx_comp3
    meta_filename: /home/cody/gr-MATLAB/TDMA_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: sdr1_st
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: sdr2_st
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: sdr2_lfm
  states: {}
- name: virtual_sink_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rx_st1
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rx_st2
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rx_lfm2
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rx_lfm2_cb
  states: {}
- name: virtual_sink_0_0_0_0_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: final_rx2
  states: {}
- name: virtual_sink_0_0_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: rx_st3
  states: {}
- name: virtual_sink_0_0_0_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: rx_lfm3
  states: {}
- name: virtual_sink_0_0_0_0_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: rx_lfm3_cb
  states: {}
- name: virtual_sink_0_0_0_0_0_0_1_0_1
  id: virtual_sink
  parameters:
    stream_id: final_rx3
  states: {}
- name: virtual_sink_0_0_0_0_0_0_2
  id: virtual_sink
  parameters:
    stream_id: rx_lfm
  states: {}
- name: virtual_sink_0_0_0_0_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: rx_lfm1_cb
  states: {}
- name: virtual_sink_0_0_0_0_0_0_2_1
  id: virtual_sink
  parameters:
    stream_id: final_rx1
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: sdr3_st
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: sdr3_lfm
  states: {}
- name: virtual_sink_0_0_2
  id: virtual_sink
  parameters:
    stream_id: sdr1_lfm
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: cp_est
  states: {}
- name: virtual_sink_0_1_1
  id: virtual_sink
  parameters:
    stream_id: ideal_lfm1
  states: {}
- name: virtual_sink_0_1_1_0
  id: virtual_sink
  parameters:
    stream_id: ideal_lfm2
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: rx_comp1
  states: {}
- name: virtual_sink_0_2_0
  id: virtual_sink
  parameters:
    stream_id: rx_comp2
  states: {}
- name: virtual_sink_0_2_0_0
  id: virtual_sink
  parameters:
    stream_id: rx_comp3
  states: {}
- name: virtual_sink_0_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rx2_comp3
  states: {}
- name: virtual_sink_0_2_0_1
  id: virtual_sink
  parameters:
    stream_id: rx2_comp2
  states: {}
- name: virtual_sink_0_2_1
  id: virtual_sink
  parameters:
    stream_id: rx2_comp1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {state: disabled}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {state: disabled}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cp_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cp_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: cp_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_1
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_0_0_2
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_1
  id: virtual_source
  parameters:
    stream_id: cb_est
  states: {}
- name: virtual_source_0_0_0_2_1_0
  id: virtual_source
  parameters:
    stream_id: cp_est
  states: {}
- name: virtual_source_0_0_0_2_1_0_0
  id: virtual_source
  parameters:
    stream_id: cp_est
  states: {}
- name: virtual_source_0_0_0_2_1_0_1
  id: virtual_source
  parameters:
    stream_id: cp_est
  states: {}
- name: virtual_source_0_0_0_3
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_0_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_0_1
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_1
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_0_1_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_1
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_1_0
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_1_1
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_1_2
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_1_3
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_1_4
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_0_0_3_1_5
  id: virtual_source
  parameters:
    stream_id: cd_est
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: sdr1_st
  states: {}
- name: virtual_source_0_3_0
  id: virtual_source
  parameters:
    stream_id: sdr3_st
  states: {}
- name: virtual_source_0_3_0_0
  id: virtual_source
  parameters:
    stream_id: ideal_lfm1
  states: {}
- name: virtual_source_0_3_0_0_0
  id: virtual_source
  parameters:
    stream_id: sdr3_lfm
  states: {}
- name: virtual_source_0_3_0_0_1
  id: virtual_source
  parameters:
    stream_id: ideal_lfm2
  states: {}
- name: virtual_source_0_3_0_1
  id: virtual_source
  parameters:
    stream_id: rx_comp1
  states: {}
- name: virtual_source_0_3_0_1_0
  id: virtual_source
  parameters:
    stream_id: rx_comp2
  states: {}
- name: virtual_source_0_3_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: rx_comp3
  states: {}
- name: virtual_source_0_3_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm3
  states: {}
- name: virtual_source_0_3_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm3_cb
  states: {}
- name: virtual_source_0_3_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: final_rx3
  states: {}
- name: virtual_source_0_3_0_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: final_rx1
  states: {}
- name: virtual_source_0_3_0_1_0_0_2
  id: virtual_source
  parameters:
    stream_id: final_rx2
  states: {}
- name: virtual_source_0_3_0_1_0_0_3
  id: virtual_source
  parameters:
    stream_id: final_rx3
  states: {}
- name: virtual_source_0_3_0_1_0_0_4
  id: virtual_source
  parameters:
    stream_id: rx2_comp3
  states: {}
- name: virtual_source_0_3_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: rx_st1
  states: {}
- name: virtual_source_0_3_0_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: rx_st2
  states: {}
- name: virtual_source_0_3_0_1_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: rx_st2
  states: {}
- name: virtual_source_0_3_0_1_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm2
  states: {}
- name: virtual_source_0_3_0_1_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm2_cb
  states: {}
- name: virtual_source_0_3_0_1_0_1_1
  id: virtual_source
  parameters:
    stream_id: rx_st3
  states: {}
- name: virtual_source_0_3_0_1_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: rx_st3
  states: {}
- name: virtual_source_0_3_0_1_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm3
  states: {}
- name: virtual_source_0_3_0_1_0_1_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm3_cb
  states: {}
- name: virtual_source_0_3_0_1_0_1_2
  id: virtual_source
  parameters:
    stream_id: rx_st1
  states: {}
- name: virtual_source_0_3_0_1_0_1_2_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm
  states: {}
- name: virtual_source_0_3_0_1_0_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm1_cb
  states: {}
- name: virtual_source_0_3_0_1_0_2
  id: virtual_source
  parameters:
    stream_id: rx_lfm2
  states: {}
- name: virtual_source_0_3_0_1_0_2_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm2_cb
  states: {}
- name: virtual_source_0_3_0_1_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: final_rx2
  states: {}
- name: virtual_source_0_3_0_1_0_3
  id: virtual_source
  parameters:
    stream_id: rx2_comp2
  states: {}
- name: virtual_source_0_3_0_1_1
  id: virtual_source
  parameters:
    stream_id: rx_lfm
  states: {}
- name: virtual_source_0_3_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: rx_lfm1_cb
  states: {}
- name: virtual_source_0_3_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: final_rx1
  states: {}
- name: virtual_source_0_3_0_1_2
  id: virtual_source
  parameters:
    stream_id: rx2_comp1
  states: {}
- name: virtual_source_0_3_1
  id: virtual_source
  parameters:
    stream_id: sdr2_st
  states: {}
- name: virtual_source_0_3_1_0
  id: virtual_source
  parameters:
    stream_id: ideal_lfm1
  states: {}
- name: virtual_source_0_3_1_0_0
  id: virtual_source
  parameters:
    stream_id: sdr2_lfm
  states: {}
- name: virtual_source_0_3_1_0_1
  id: virtual_source
  parameters:
    stream_id: ideal_lfm2
  states: {}
- name: virtual_source_0_3_2
  id: virtual_source
  parameters:
    stream_id: ideal_lfm1
  states: {}
- name: virtual_source_0_3_2_0
  id: virtual_source
  parameters:
    stream_id: sdr1_lfm
  states: {}
- name: virtual_source_0_3_2_1
  id: virtual_source
  parameters:
    stream_id: ideal_lfm2
  states: {}

connections:
- [harmonia_LFM_src_0, out, plasma_pdu_file_sink_0_0_0, in]
- [harmonia_LFM_src_0, out, virtual_sink_0_0_2, '0']
- [harmonia_LFM_src_0_0, out, plasma_pdu_file_sink_0_0_0_1, in]
- [harmonia_LFM_src_0_0, out, virtual_sink_0_0_0_0, '0']
- [harmonia_LFM_src_0_1, out, plasma_pdu_file_sink_0_0_0_2, in]
- [harmonia_LFM_src_0_1, out, virtual_sink_0_0_1_0, '0']
- [harmonia_LFM_src_0_2, out, virtual_sink_0_1_1, '0']
- [harmonia_LFM_src_0_2_0, out, virtual_sink_0_1_1_0, '0']
- [harmonia_clock_drift_est_0, out, virtual_sink_0, '0']
- [harmonia_clockbias_phase_est_0, out, virtual_sink_0_1, '0']
- [harmonia_clockbias_phase_est_0_0, out, virtual_sink_0_1_0, '0']
- [harmonia_compensation_0, out, plasma_pdu_file_sink_0_0_2_0_1, in]
- [harmonia_compensation_0, out, virtual_sink_0_2, '0']
- [harmonia_compensation_0_0, out, plasma_pdu_file_sink_0_0_2_0_1_0, in]
- [harmonia_compensation_0_0, out, virtual_sink_0_2_0, '0']
- [harmonia_compensation_0_0_0, out, plasma_pdu_file_sink_0_0_2_0_1_0_0_0, in]
- [harmonia_compensation_0_0_0, out, virtual_sink_0_2_0_1, '0']
- [harmonia_compensation_0_0_0_0, out, plasma_pdu_file_sink_0_0_3_0_0_0_1_1_0, in]
- [harmonia_compensation_0_1, out, plasma_pdu_file_sink_0_0_2_0_1_1, in]
- [harmonia_compensation_0_1, out, virtual_sink_0_2_0_0, '0']
- [harmonia_compensation_0_1_0, out, plasma_pdu_file_sink_0_0_2_0_1_0_0_1, in]
- [harmonia_compensation_0_1_0, out, virtual_sink_0_2_0_0_0, '0']
- [harmonia_compensation_0_1_0_0, out, plasma_pdu_file_sink_0_0_3_0_0_0_1_1_1, in]
- [harmonia_compensation_0_2, out, plasma_pdu_file_sink_0_0_2_0_1_0_0, in]
- [harmonia_compensation_0_2, out, virtual_sink_0_2_1, '0']
- [harmonia_compensation_0_2_0, out, plasma_pdu_file_sink_0_0_3_0_0_0_1_1, in]
- [harmonia_frequency_pk_est_0, f_out, harmonia_clock_drift_est_0, in]
- [harmonia_frequency_pk_est_0_0, f_out, harmonia_clock_drift_est_0, in3]
- [harmonia_frequency_pk_est_0_1, f_out, harmonia_clock_drift_est_0, in2]
- [harmonia_single_tone_src_0, out, virtual_sink_0_0_1, '0']
- [harmonia_single_tone_src_0_0, out, virtual_sink_0_0, '0']
- [harmonia_single_tone_src_0_1, out, virtual_sink_0_0_0, '0']
- [harmonia_time_pk_est_0, tp_out, harmonia_clockbias_phase_est_0, in]
- [harmonia_time_pk_est_0_0, tp_out, harmonia_clockbias_phase_est_0, in2]
- [harmonia_time_pk_est_0_0_0, tp_out, harmonia_clockbias_phase_est_0_0, in2]
- [harmonia_time_pk_est_0_1, tp_out, harmonia_clockbias_phase_est_0, in3]
- [harmonia_time_pk_est_0_1_0, tp_out, harmonia_clockbias_phase_est_0_0, in3]
- [harmonia_time_pk_est_0_2, tp_out, harmonia_clockbias_phase_est_0_0, in]
- [harmonia_usrp_radar_all_0, cb_out, virtual_sink_0_0_0_0_0_0_2_0, '0']
- [harmonia_usrp_radar_all_0, cb_out2, virtual_sink_0_0_0_0_0_0_0_0_0, '0']
- [harmonia_usrp_radar_all_0, cb_out3, virtual_sink_0_0_0_0_0_0_1_0_0, '0']
- [harmonia_usrp_radar_all_0, cd_out, virtual_sink_0_0_0_0_0_0_2, '0']
- [harmonia_usrp_radar_all_0, cd_out2, virtual_sink_0_0_0_0_0_0_0_0, '0']
- [harmonia_usrp_radar_all_0, cd_out3, virtual_sink_0_0_0_0_0_0_1_0, '0']
- [harmonia_usrp_radar_all_0, cp_out, virtual_sink_0_0_0_0_0_0_2_1, '0']
- [harmonia_usrp_radar_all_0, cp_out2, virtual_sink_0_0_0_0_0_0_0_0_1, '0']
- [harmonia_usrp_radar_all_0, cp_out3, virtual_sink_0_0_0_0_0_0_1_0_1, '0']
- [harmonia_usrp_radar_all_0, out, virtual_sink_0_0_0_0_0_0, '0']
- [harmonia_usrp_radar_all_0, out2, virtual_sink_0_0_0_0_0_0_0, '0']
- [harmonia_usrp_radar_all_0, out3, virtual_sink_0_0_0_0_0_0_1, '0']
- [virtual_source_0_0_0, '0', harmonia_LFM_src_0, cd_in]
- [virtual_source_0_0_0_0, '0', harmonia_LFM_src_0_0, cd_in]
- [virtual_source_0_0_0_0_0, '0', plasma_pdu_file_sink_0_0_0_0_0, in]
- [virtual_source_0_0_0_0_0_0, '0', plasma_pdu_file_sink_0_0_0_0_0_0, in]
- [virtual_source_0_0_0_1, '0', harmonia_LFM_src_0_1, cd_in]
- [virtual_source_0_0_0_2, '0', harmonia_LFM_src_0, cb_in]
- [virtual_source_0_0_0_2_0, '0', harmonia_LFM_src_0_0, cb_in]
- [virtual_source_0_0_0_2_0_0, '0', harmonia_compensation_0_2, cb_in]
- [virtual_source_0_0_0_2_0_0_0, '0', harmonia_compensation_0_0_0, cb_in]
- [virtual_source_0_0_0_2_0_0_0_0, '0', harmonia_compensation_0_0_0_0, cb_in]
- [virtual_source_0_0_0_2_0_0_0_0_0, '0', harmonia_compensation_0_0_0_0, cp_in]
- [virtual_source_0_0_0_2_0_0_0_0_0_0, '0', harmonia_compensation_0_2_0, cp_in]
- [virtual_source_0_0_0_2_0_0_0_0_0_1, '0', harmonia_compensation_0_1_0_0, cp_in]
- [virtual_source_0_0_0_2_0_0_1, '0', harmonia_compensation_0_1_0, cb_in]
- [virtual_source_0_0_0_2_0_0_1_0, '0', harmonia_compensation_0_1_0_0, cb_in]
- [virtual_source_0_0_0_2_0_0_2, '0', harmonia_compensation_0_2_0, cb_in]
- [virtual_source_0_0_0_2_1, '0', harmonia_LFM_src_0_1, cb_in]
- [virtual_source_0_0_0_2_1_0, '0', harmonia_LFM_src_0_1, cp_in]
- [virtual_source_0_0_0_2_1_0_0, '0', harmonia_LFM_src_0_0, cp_in]
- [virtual_source_0_0_0_2_1_0_1, '0', harmonia_LFM_src_0, cp_in]
- [virtual_source_0_0_0_3, '0', harmonia_clockbias_phase_est_0, cd_in]
- [virtual_source_0_0_0_3_0, '0', harmonia_compensation_0, cd_in]
- [virtual_source_0_0_0_3_0_0, '0', harmonia_compensation_0_0, cd_in]
- [virtual_source_0_0_0_3_0_0_0, '0', harmonia_compensation_0_1, cd_in]
- [virtual_source_0_0_0_3_0_0_0_0, '0', harmonia_compensation_0_1_0, cd_in]
- [virtual_source_0_0_0_3_0_0_0_0_0, '0', harmonia_compensation_0_1_0_0, cd_in]
- [virtual_source_0_0_0_3_0_0_1, '0', harmonia_compensation_0_0_0, cd_in]
- [virtual_source_0_0_0_3_0_0_1_0, '0', harmonia_compensation_0_0_0_0, cd_in]
- [virtual_source_0_0_0_3_0_1, '0', harmonia_compensation_0_2, cd_in]
- [virtual_source_0_0_0_3_0_1_0, '0', harmonia_compensation_0_2_0, cd_in]
- [virtual_source_0_0_0_3_1, '0', harmonia_clockbias_phase_est_0_0, cd_in]
- [virtual_source_0_0_0_3_1_0, '0', harmonia_time_pk_est_0_1_0, cd_in]
- [virtual_source_0_0_0_3_1_1, '0', harmonia_time_pk_est_0_2, cd_in]
- [virtual_source_0_0_0_3_1_2, '0', harmonia_time_pk_est_0_0_0, cd_in]
- [virtual_source_0_0_0_3_1_3, '0', harmonia_time_pk_est_0_0, cd_in]
- [virtual_source_0_0_0_3_1_4, '0', harmonia_time_pk_est_0_1, cd_in]
- [virtual_source_0_0_0_3_1_5, '0', harmonia_time_pk_est_0, cd_in]
- [virtual_source_0_3, '0', harmonia_usrp_radar_all_0, in]
- [virtual_source_0_3_0, '0', harmonia_usrp_radar_all_0, in3]
- [virtual_source_0_3_0_0, '0', harmonia_time_pk_est_0_1, tx]
- [virtual_source_0_3_0_0_0, '0', harmonia_usrp_radar_all_0, LFM_in3]
- [virtual_source_0_3_0_0_1, '0', harmonia_time_pk_est_0_1_0, tx]
- [virtual_source_0_3_0_1, '0', harmonia_time_pk_est_0, rx]
- [virtual_source_0_3_0_1_0, '0', harmonia_time_pk_est_0_0, rx]
- [virtual_source_0_3_0_1_0_0, '0', harmonia_time_pk_est_0_1, rx]
- [virtual_source_0_3_0_1_0_0_0, '0', harmonia_compensation_0_1, in]
- [virtual_source_0_3_0_1_0_0_0_0, '0', harmonia_compensation_0_1_0, in]
- [virtual_source_0_3_0_1_0_0_0_0_0, '0', harmonia_compensation_0_1_0_0, in]
- [virtual_source_0_3_0_1_0_0_1, '0', plasma_pdu_file_sink_0_0_2_0_0_0, in]
- [virtual_source_0_3_0_1_0_0_2, '0', plasma_pdu_file_sink_0_0_2_0_0_1, in]
- [virtual_source_0_3_0_1_0_0_3, '0', plasma_pdu_file_sink_0_0_2_0_0_2, in]
- [virtual_source_0_3_0_1_0_0_4, '0', harmonia_time_pk_est_0_1_0, rx]
- [virtual_source_0_3_0_1_0_1, '0', harmonia_frequency_pk_est_0, in]
- [virtual_source_0_3_0_1_0_1_0, '0', harmonia_frequency_pk_est_0_1, in]
- [virtual_source_0_3_0_1_0_1_0_0, '0', plasma_pdu_file_sink_0_0_2, in]
- [virtual_source_0_3_0_1_0_1_0_0_0, '0', plasma_pdu_file_sink_0_0_2_0, in]
- [virtual_source_0_3_0_1_0_1_0_0_0_0, '0', plasma_pdu_file_sink_0_0_2_0_0, in]
- [virtual_source_0_3_0_1_0_1_1, '0', harmonia_frequency_pk_est_0_0, in]
- [virtual_source_0_3_0_1_0_1_1_0, '0', plasma_pdu_file_sink_0_0_3, in]
- [virtual_source_0_3_0_1_0_1_1_0_0, '0', plasma_pdu_file_sink_0_0_3_0, in]
- [virtual_source_0_3_0_1_0_1_1_0_0_0, '0', plasma_pdu_file_sink_0_0_3_0_0, in]
- [virtual_source_0_3_0_1_0_1_2, '0', plasma_pdu_file_sink_0_0, in]
- [virtual_source_0_3_0_1_0_1_2_0, '0', plasma_pdu_file_sink_0_0_1, in]
- [virtual_source_0_3_0_1_0_1_2_0_0, '0', plasma_pdu_file_sink_0_0_1_0, in]
- [virtual_source_0_3_0_1_0_2, '0', harmonia_compensation_0_0, in]
- [virtual_source_0_3_0_1_0_2_0, '0', harmonia_compensation_0_0_0, in]
- [virtual_source_0_3_0_1_0_2_0_0, '0', harmonia_compensation_0_0_0_0, in]
- [virtual_source_0_3_0_1_0_3, '0', harmonia_time_pk_est_0_0_0, rx]
- [virtual_source_0_3_0_1_1, '0', harmonia_compensation_0, in]
- [virtual_source_0_3_0_1_1_0, '0', harmonia_compensation_0_2, in]
- [virtual_source_0_3_0_1_1_0_0, '0', harmonia_compensation_0_2_0, in]
- [virtual_source_0_3_0_1_2, '0', harmonia_time_pk_est_0_2, rx]
- [virtual_source_0_3_1, '0', harmonia_usrp_radar_all_0, in2]
- [virtual_source_0_3_1_0, '0', harmonia_time_pk_est_0_0, tx]
- [virtual_source_0_3_1_0_0, '0', harmonia_usrp_radar_all_0, LFM_in2]
- [virtual_source_0_3_1_0_1, '0', harmonia_time_pk_est_0_0_0, tx]
- [virtual_source_0_3_2, '0', harmonia_time_pk_est_0, tx]
- [virtual_source_0_3_2_0, '0', harmonia_usrp_radar_all_0, LFM_in]
- [virtual_source_0_3_2_1, '0', harmonia_time_pk_est_0_2, tx]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
