options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: time_peak_estimation_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Tc
  id: variable
  parameters:
    value: '200e-3'
  states: {}
- name: Tp
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: bw
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: prf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: harmonia_buffer_corrector_0
  id: harmonia_buffer_corrector
  parameters:
    max_buffer_size: '1996'
  states: {}
- name: harmonia_time_pk_est_0
  id: harmonia_time_pk_est
  parameters:
    NLLS_iter: '15'
    NLLS_pts: '7'
    backend: plasma.Device.CPU
    bandwidth: bw
    current_sdr: PMT_HARMONIA_SDR1
    depth: '10000'
    nfft: '4'
    samp_rate: samp_rate
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    TDMA_time_slot: '0'
    args_1: '"addr=192.168.60.2, use_dpkg=1"'
    args_2: '"addr=192.168.80.2, use_dpkg=1"'
    cap_length: Tc
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '20'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '10'
    start_delay: '0.1'
    verbose: 'False'
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: prf
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: center_freq-bw/2
    start_freq_key: radar:start_freq
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Peak"'
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RX"'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"TX"'
    srate: samp_rate
    type: msg_complex
  states: {state: disabled}

connections:
- [harmonia_buffer_corrector_0, out, harmonia_usrp_radar_all_0, in]
- [harmonia_time_pk_est_0, out, blocks_message_debug_0, print]
- [harmonia_time_pk_est_0, out, qtgui_time_sink_x_0, in]
- [harmonia_usrp_radar_all_0, out, harmonia_time_pk_est_0, rx]
- [harmonia_usrp_radar_all_0, out, qtgui_time_sink_x_0_0, in]
- [plasma_lfm_source_0, out, harmonia_buffer_corrector_0, in]
- [plasma_lfm_source_0, out, harmonia_time_pk_est_0, tx]
- [plasma_lfm_source_0, out, qtgui_time_sink_x_0_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
