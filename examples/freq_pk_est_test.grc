options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: Freq_Pk_Est_Test
    output_language: python
    title: Freq_Pk_Est_Test
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: harmonia_frequency_pk_est_0
  id: harmonia_frequency_pk_est
  parameters:
    NLLS_iter: '25'
    NLLS_pts: '7'
    backend: harmonia.Device.DEFAULT
    cap_length: '400e-6'
    current_sdr: PMT_HARMONIA_SDR1
    depth: '1'
    enable_out: 'False'
    nfft: '4'
    pulse_width: '200e-6'
    samp_rate: samp_rate
  states: {}
- name: harmonia_single_tone_src_0
  id: harmonia_single_tone_src
  parameters:
    duration_key: radar:duration
    frequency: 1e6
    frequency_key: radar:frequency
    label_key: core:label
    phase: '0'
    phase_key: radar:phase
    prf: '0'
    prf_key: radar:prf
    pulse_width: '200e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/freq_pk_est_test
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    type: msg_complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_float
  states: {state: disabled}

connections:
- [harmonia_frequency_pk_est_0, f_out, blocks_message_debug_0, print]
- [harmonia_single_tone_src_0, out, harmonia_frequency_pk_est_0, in]
- [harmonia_single_tone_src_0, out, qtgui_freq_sink_x_0_0, in]
- [harmonia_single_tone_src_0, out, qtgui_time_sink_x_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
