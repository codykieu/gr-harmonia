options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: clock_drift_est_test
    output_language: python
    title: Clock Drift Estimate Test
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: pulse_width
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern("sync:sdr_one"), pmt.from_float(1900000.0))
    period: '4000'
  states: {}
- name: harmonia_clock_drift_est_0
  id: harmonia_clock_drift_est
  parameters:
    SNR: '30'
    baseband_freq: 1e6
    center_freq: 1e9
    num_platforms: '3'
    platform_num: '2'
    pulse_width: pulse_width
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_message_strobe_0, strobe, harmonia_clock_drift_est_0, in]
- [harmonia_clock_drift_est_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
