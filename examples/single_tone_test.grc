options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: single_tone_test
    output_language: python
    title: single_tone_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 200e6
  states: {}
- name: harmonia_pdu_complex_to_mag_0
  id: harmonia_pdu_complex_to_mag
  parameters: {}
  states: {}
- name: plasma_cw_to_pulsed_1
  id: plasma_cw_to_pulsed
  parameters:
    prf: 10e3
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: 5e6
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '10e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '0'
    start_freq_key: radar:start_freq
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [harmonia_pdu_complex_to_mag_0, out, qtgui_time_sink_x_0, in]
- [plasma_cw_to_pulsed_1, out, harmonia_pdu_complex_to_mag_0, in]
- [plasma_cw_to_pulsed_1, out, qtgui_time_sink_x_1_1, in]
- [plasma_lfm_source_0, out, plasma_cw_to_pulsed_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
