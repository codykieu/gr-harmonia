options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: QPSK_test
    output_language: python
    title: QPSK test
  states: {}

blocks:
- name: Tp
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: prf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_vector_decimator_0
  id: blocks_stream_to_vector_decimator
  parameters:
    sample_rate: samp_rate
    type: complex
    vec_rate: '30'
    vlen: '1024'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: harmonia_buffer_corrector_0
  id: harmonia_buffer_corrector
  parameters:
    max_buffer_size: '1996'
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    args_1: '"addr=192.168.60.2, use_dpkg=1"'
    args_2: '"addr=192.168.80.2, use_dpkg=1"'
    elevate_priority: 'False'
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '20'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '20'
    start_delay: '0.1'
    verbose: 'False'
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {}
- name: plasma_pdu_file_sink_0_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: /home/cody/gr-MATLAB/QPSK_test
    meta_filename: /home/cody/gr-MATLAB/freq_pk_est_meta
    save_meta: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [harmonia_buffer_corrector_0, out, harmonia_usrp_radar_all_0, in]
- [harmonia_usrp_radar_all_0, out, plasma_pdu_file_sink_0_0, in]
- [harmonia_usrp_radar_all_0, out, qtgui_time_sink_x_0_1, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
