options:
  parameters:
    author: cody
    generate_options: qt_gui
    id: delay_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Tp
  id: variable
  parameters:
    value: '500e-6'
  states: {}
- name: bw
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: harmonia_LFM_src_0
  id: harmonia_LFM_src
  parameters:
    bandwidth: bw
    bandwidth_key: radar:bandwidth
    center_freq: center_freq
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
    start_freq: '-bw/2'
  states: {state: disabled}
- name: harmonia_single_tone_src_0_0
  id: harmonia_single_tone_src
  parameters:
    center_freq: center_freq
    duration_key: radar:duration
    frequency: 1e6
    frequency_key: radar:frequency
    label_key: core:label
    max_buffer_size: '1996'
    phase: '0'
    phase_key: radar:phase
    prf: '0'
    prf_key: radar:prf
    pulse_width: Tp
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    sdr_id: '1'
  states: {}
- name: harmonia_usrp_radar_all_0
  id: harmonia_usrp_radar_all
  parameters:
    TDMA_time: '0'
    args_1: '"addr=192.168.80.2, use_dpkg=1"'
    args_2: '"addr=192.168.60.2, use_dpkg=1"'
    args_3: '"addr=192.168.40.2, use_dpkg=1"'
    cap_length: '0.005'
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_start_key: core:sample_start
    sdr1_freq: center_freq
    sdr1_freq_key: core:tx_freq
    sdr1_gain: '0'
    sdr2_freq: center_freq
    sdr2_freq_key: core:rx_freq
    sdr2_gain: '0'
    sdr3_freq: center_freq
    sdr3_gain: '0'
    start_delay: '1.5'
    verbose: 'False'
    wait_time: '-0.001'
  states: {}
- name: plasma_pdu_file_sink_0
  id: plasma_pdu_file_sink
  parameters:
    data_filename: delay_test
    meta_filename: ''
    save_meta: 'False'
    type: complex
  states: {}

connections:
- [harmonia_LFM_src_0, out, harmonia_usrp_radar_all_0, in]
- [harmonia_single_tone_src_0_0, out, harmonia_usrp_radar_all_0, in]
- [harmonia_usrp_radar_all_0, out, plasma_pdu_file_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
